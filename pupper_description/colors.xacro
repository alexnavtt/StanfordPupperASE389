Commit message: Added pink

File: pupper_description/colors.xacro (robot description, xacro)
@@ -16,3 +16,6 @@
     <color rgba = "0 1 1 1"/>
 </material>
+<material name = "pink">
+    <color rgba = "1 0 1 1"/>
+</material>
 </robot>
